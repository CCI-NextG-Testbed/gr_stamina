options:
  parameters:
    author: joao
    generate_options: qt_gui
    id: stop_and_wait_ia
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rx_beams
  id: variable
  parameters:
    value: '[28,29,30,31, 32, 33, 34, 35, 36]'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: tx_beams
  id: variable
  parameters:
    value: '[28,29,30,31, 32, 33, 34, 35, 36]'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: beam_period
  id: parameter
  parameters:
    type: eng_float
    value: '0.05'
  states: {}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '200'
    type: byte
  states: {}
- name: center_freq
  id: parameter
  parameters:
    value: 5.3e9
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"pdu_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"packet_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: fft_len
  id: parameter
  parameters:
    type: intx
    value: '64'
  states: {}
- name: file_suffix
  id: parameter
  parameters:
    type: str
    value: test
  states: {}
- name: ia_interval
  id: parameter
  parameters:
    type: eng_float
    value: '2'
  states: {}
- name: meas_period
  id: parameter
  parameters:
    type: eng_float
    value: '10e-3'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*2
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: stamina_beam_mapper_0
  id: stamina_beam_mapper
  parameters:
    backoff: '2e-6'
    config_path: /home/user/gpio_map.json
    debug: 'True'
    pulse: '2e-6'
    rx_mhu: MHU2
    tx_mhu: MHU1
  states: {}
- name: stamina_beam_selector_0
  id: stamina_beam_selector
  parameters:
    debug: 'True'
    kpi_file: '"/home/user/sel_kpi_" + file_suffix + ".log"'
    pair_file: '"/home/user/sel_pair_" + file_suffix + ".log"'
    threshold: '0.0'
  states: {}
- name: stamina_beam_sweep_0
  id: stamina_beam_sweep
  parameters:
    beam_period: beam_period
    debug: 'True'
    interval: ia_interval
    rx_iterable: rx_beams
    standalone: 'False'
    tx_iterable: tx_beams
  states: {}
- name: stamina_kpi_agg_0
  id: stamina_kpi_agg
  parameters:
    beam_file: '"/home/user/kpi_beam_" + file_suffix + ".log"'
    debug: 'True'
    meas_file: '"/home/user/kpi_meas_" + file_suffix + ".log"'
    meas_period: meas_period
    sensitivity: '-90.0'
    standalone: 'False'
    type: float
  states: {}
- name: stamina_rate_measure_0
  id: stamina_rate_measure
  parameters:
    debug: 'False'
    meas_file: '"/home/user/rate_meas_" + file_suffix + ".log"'
    meas_period: '1e-3'
  states: {}
- name: stamina_rss_calc_0_0
  id: stamina_rss_calc
  parameters:
    length: '1000'
    max_iter: '4000'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '0.700'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 0.5*samp_rate
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 0.5*samp_rate
    center_freq0: center_freq
    dev_args: '""'
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [digital_ofdm_rx_0, '0', stamina_rate_measure_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [stamina_beam_mapper_0, gpio_cmd, uhd_usrp_sink_0_0, command]
- [stamina_beam_selector_0, sweep, stamina_beam_sweep_0, sweep]
- [stamina_beam_sweep_0, beam_id, stamina_beam_mapper_0, beam_id]
- [stamina_beam_sweep_0, beam_id, stamina_kpi_agg_0, beam_id]
- [stamina_beam_sweep_0, trigger, stamina_beam_selector_0, trigger]
- [stamina_beam_sweep_0, trigger, stamina_kpi_agg_0, trigger]
- [stamina_beam_sweep_0, trigger, stamina_rate_measure_0, trigger]
- [stamina_kpi_agg_0, kpi_out, stamina_beam_selector_0, kpi_in]
- [stamina_rss_calc_0_0, '0', stamina_kpi_agg_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', stamina_rss_calc_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.5.0-62-gf520c346
